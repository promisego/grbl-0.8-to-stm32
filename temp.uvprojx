# Keil uVision project temp.uvprojx, settings and files
target temp (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temp +hex
  c flags: Optim=1
  c include: .\lib\inc;.\user;.\SYSTEM;.\GRBL;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c
  group lib
    ./lib/src/: stm32f10x_rcc.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_usart.c
  group start
    ./start/: cortexm3_macro.s stm32f10x_vector.s
  group system
    ./SYSTEM/: system.c delay.c
  group HARDWARE
    ./HARDWARE/: HW_GPIO.c HW_EEPROM.c HW_TIM.c HW_USART.c HW_EXTI.c
  group GRBL
    ./GRBL/: stepper.c serial.c limits.c protocol.c spindle_control.c coolant_control.c nuts_bolts.c eeprom.c report.c print.c settings.c motion_control.c gcode.c planner.c
