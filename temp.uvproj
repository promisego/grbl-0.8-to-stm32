# Keil uVision project temp.uvproj, settings and files
target temp (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: temp +hex
  c flags: Optim=1
  c include: .\lib\inc;.\user;.\SYSTEM;.\GRBL;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c
  group lib
    ./lib/src/: stm32f10x_rcc.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_usart.c
  group start
    ./start/: cortexm3_macro.s stm32f10x_vector.s
  group system
    ./SYSTEM/: system.c delay.c
  group HARDWARE
    ./HARDWARE/: HW_GPIO.c HW_EEPROM.c HW_TIM.c HW_USART.c HW_EXTI.c
  group GRBL
    ./GRBL/: stepper.c serial.c limits.c protocol.c spindle_control.c coolant_control.c nuts_bolts.c eeprom.c report.c print.c settings.c motion_control.c gcode.c planner.c
